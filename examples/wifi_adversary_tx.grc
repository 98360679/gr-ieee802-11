options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_adversary_tx
    output_language: python
    realtime_scheduling: '1'
    run_options: run
  states: {}

blocks:
- name: adv_gain
  id: variable_qtgui_range
  parameters:
    comment: Adversary USRP TX gain (OTA power of the perturbation)
    label: Adversary TX gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: adv_gain_abs
  id: variable_qtgui_range
  parameters:
    label: Adversary Gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '22'
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    comment: Adversarial perturbation strength (Kim et al. epsilon)
    label: Perturbation strength (epsilon)
    start: '0'
    step: '0.01'
    stop: '4'
    value: '0'
  states: {}
- name: frame_file
  id: variable
  parameters:
    comment: Legit device frame to replay, looped (complex64 IQ at samp_rate)
    value: '"/dev/shm/frame.bin"'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2452000000.0'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: 6e6
  states: {}
- name: normalized_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '500'
  states: {}
- name: pert_file
  id: variable
  parameters:
    comment: Pre-computed channel-aware perturbation (complex64 IQ at samp_rate)
    value: '"/dev/shm/perturbation.bin"'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 5e6
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: TX frequency
    start: 2.4e9
    step: 1e6
    stop: 5.5e9
    value: 2.450e9
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Normalized gain
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: tx_gain_abs
  id: variable_qtgui_range
  parameters:
    label: Absolute gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '22'
  states: {}
- name: blocks_file_source_frame
  id: blocks_file_source
  parameters:
    comment: Legit device frame, looped continuously (replay). Same length L as the perturbation so the two channels stay sample-aligned. Complex64 IQ @ samp_rate.
    file: frame_file
    minoutbuf: out_buf_size
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_pert
  id: blocks_file_source
  parameters:
    comment: Channel-aware adversarial perturbation generated offline (FGSM/PGD vs SARP, Kim et al.). Complex64 IQ @ samp_rate.
    file: pert_file
    minoutbuf: out_buf_size
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    period: interval
  states: {state: disabled}
- name: blocks_multiply_const_pert
  id: blocks_multiply_const_vxx
  parameters:
    comment: Scale perturbation by epsilon
    const: epsilon
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    minoutbuf: '100000'
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0,)
  states: {state: disabled}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: out_buf_size
    pad_front: '100'
    pad_tail: '1000'
  states: {state: disabled}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 255]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {state: disabled}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: qtgui_freq_sink_pert
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"magenta"'
    comment: Tap on the scaled perturbation (post-epsilon) as it goes to USRP ch1
    fc: '0'
    fftsize: '1024'
    label1: Perturbation
    name: '"Adversary Perturbation Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: snippet_time_sync
  id: snippet
  parameters:
    code: |
      import time
      # 2-mboard MIMO: master internal clock, slave off the MIMO cable.
      # set_time_now avoids the N-series PPS crash; a common start_time aligns both.
      time.sleep(1.0)

      self.uhd_usrp_sink_0.set_time_now(uhd.time_spec(0.0))

      time.sleep(0.2)

      t_start = self.uhd_usrp_sink_0.get_time_now() + uhd.time_spec(3.0)

      self.uhd_usrp_sink_0.set_start_time(t_start)

      print(f"DEBUG: synchronized start at {t_start.get_real_secs()}s")
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: J2
    ant1: J2
    center_freq0: uhd.tune_request(tx_freq, rf_freq = tx_freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    center_freq1: uhd.tune_request(tx_freq, rf_freq = tx_freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    clock_source0: internal
    clock_source1: mimo
    dev_addr: addr0=192.168.10.3,addr1=192.168.10.5
    dev_args: '""'
    gain0: tx_gain_abs
    gain1: adv_gain_abs
    len_tag_name: ''
    nchan: '2'
    num_mboards: '2'
    samp_rate: samp_rate
    sync: sync
    time_source1: mimo
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.LS
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {state: disabled}

connections:
- [blocks_file_source_frame, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_frame, '0', uhd_usrp_sink_0, '0']
- [blocks_file_source_pert, '0', blocks_multiply_const_pert, '0']
- [blocks_multiply_const_pert, '0', qtgui_freq_sink_pert, '0']
- [blocks_multiply_const_pert, '0', uhd_usrp_sink_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
