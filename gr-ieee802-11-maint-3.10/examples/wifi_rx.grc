options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: device_id
  id: variable
  parameters:
    value: '6'
  states: {}
- name: eps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2450.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'',  '' 33 | 3300.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2450000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 3300000000.0,5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2450000000.0'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: psr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: run_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.750'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 5e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/wifi.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: '''/media/hlado2/T9/Data/session13/clean/device_%d//clean_run_%d.bin''%(device_id,run_id)'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tag_share_0
  id: blocks_tag_share
  parameters:
    io_type: complex
    share_type: complex
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("strobe")
    nsamps: '1000'
    type: complex
    value: pmt.intern("TEST")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: frame_logger
  id: epy_block
  parameters:
    _source_code: |
      """
      frame_logger - append each decoded 802.11 frame (frame_id + payload)
      to a JSONL file for the closed-loop adversarial pipeline.

      The TX (exp3_wifi_tx.py) builds each MSDU as
          b'FRID' + uint32_be(frame_id) + b'x'*filler
      and decode_mac publishes cons(meta, blob) where blob is the PSDU minus
      FCS (24-byte MAC header + MSDU). decode_mac drops CRC-failed frames, so
      every record written here is a CRC-valid decode. A frame is "ours" iff
      its MSDU begins with the FRID magic.
      """

      import json
      import struct
      import time
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Log decoded frames (frame_id + payload_hex) to a JSONL file."""

          MAC_HDR_LEN = 24       # 802.11 data-frame header, stripped to reach the MSDU
          MAGIC = b'FRID'        # MSDU marker: b'FRID' + uint32_be(frame_id) + b'x'*filler

          def __init__(self, log_path='/tmp/rx_frames.jsonl'):
              gr.basic_block.__init__(self, name='frame_logger',
                                      in_sig=[], out_sig=[])
              self._log_path = log_path
              self._n = 0
              self._skipped = 0
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle)

          def handle(self, msg):
              try:
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception:
                  return
              # MSDU = decoded frame minus the 24-byte MAC header.
              msdu = data[self.MAC_HDR_LEN:]
              # Keep only our TX frames (MSDU starts with FRID magic); drop ambient WiFi.
              if msdu[:4] != self.MAGIC or len(msdu) < 8:
                  self._skipped += 1
                  print('[frame_logger] skip ambient (#%d skipped) len=%d'
                        % (self._skipped, len(data)))
                  return
              frame_id = struct.unpack('>I', msdu[4:8])[0]
              self._n += 1
              rec = {
                  'seq': self._n,
                  't': time.time(),
                  'frame_id': frame_id,
                  'len': len(data),
                  'payload_hex': data.hex(),
              }
              with open(self._log_path, 'a') as f:
                  f.write(json.dumps(rec) + '\n')
              print('[frame_logger] #%d id=%s len=%d -> %s'
                    % (self._n, frame_id, len(data), self._log_path))
    log_path: '''/media/hlado2/T9/Data/session14/enrollment/device_%d/rx_frames_run_%d.jsonl''%(device_id,run_id)'
  states: {}
- name: link_stats
  id: epy_block
  parameters:
    _source_code: |
      """
      link_stats — live decode-rate / loss readout for the FRID closed loop
      ─────────────────────────────────────────────────────────────────────
      Drop this into wifi_rx.grc as a GRC **Python Block** (Embedded Python Block),
      and wire  decode_mac 'out'  ->  this block's 'in'  (same source as frame_logger).

      Why decode-rate, not BER: decode_mac only emits CRC-VALID frames on 'out', and a
      CRC-valid frame is error-free — so live BER off this port is always ~0 and
      useless. Instead we exploit that the TX stamps SEQUENTIAL frame_ids (FRID): the
      fraction of the transmitted id-range we actually decode is the real link-quality
      signal. Tune rx_gain to MAXIMIZE the "decode-rate now" number.

      Prints every `report_sec`:
        decode-rate now  : decoded / id-advance over the LAST interval  (the tuning knob)
        cum              : unique decoded / full id span               (overall)
        fps              : CRC-valid frames per second
        ambient-skip     : non-FRID frames seen (other WiFi / false syncs) — high = noisy

      GRC: id `link_stats`, one message input port 'in', no outputs. Param: report_sec.
      """
      import time
      import struct
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          MAC_HDR_LEN = 24            # 802.11 data-frame header before the MSDU
          MAGIC = b'FRID'            # MSDU marker: b'FRID' + uint32_be(frame_id) + 'x'*fill

          def __init__(self, report_sec=2.0):
              gr.basic_block.__init__(self, name='link_stats', in_sig=[], out_sig=[])
              self.report_sec = float(report_sec)
              self.ids = set()           # unique frame_ids decoded
              self.n = 0                 # total CRC-valid FRID frames
              self.skipped = 0           # non-FRID frames (ambient / false sync)
              self.id_min = None
              self.id_max = None
              # interval bookkeeping for the "now" rate
              self.t_last = time.time()
              self.n_last = 0
              self.id_max_last = None
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle)

          def handle(self, msg):
              try:
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception:
                  return
              msdu = data[self.MAC_HDR_LEN:]
              if msdu[:4] != self.MAGIC or len(msdu) < 8:
                  self.skipped += 1          # not ours: ambient WiFi or a false decode
                  return
              fid = struct.unpack('>I', msdu[4:8])[0]
              self.ids.add(fid)
              self.n += 1
              if self.id_min is None or fid < self.id_min:
                  self.id_min = fid
              if self.id_max is None or fid > self.id_max:
                  self.id_max = fid

              now = time.time()
              if now - self.t_last >= self.report_sec and self.id_max is not None:
                  # recent interval: how many ids advanced vs how many we decoded
                  base = self.id_max_last if self.id_max_last is not None else self.id_min
                  d_span = self.id_max - base
                  d_dec = self.n - self.n_last
                  recent = min(100.0, 100.0 * d_dec / d_span) if d_span > 0 else 0.0
                  # cumulative
                  span = self.id_max - self.id_min + 1
                  cum = 100.0 * len(self.ids) / span if span else 0.0
                  fps = d_dec / (now - self.t_last)
                  print('[link_stats] decode-rate now %5.1f%%   cum %5.1f%% (%d/%d)   '
                        '%5.1f fps   ambient-skip %d'
                        % (recent, cum, len(self.ids), span, fps, self.skipped))
                  self.t_last = now
                  self.n_last = self.n
                  self.id_max_last = self.id_max
    report_sec: '2.0'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, rf_freq = freq - lo_offset, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)
    clock_rate: '0.0'
    dev_addr: '"serial=325936A"'
    dev_args: '""'
    gain0: rx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: ber_sink_0
  id: epy_block
  parameters:
    _source_code: |
      """
      ber_sink - live BER/FER for the FRID closed loop (per-frame-seeded payload).

      Consumes decode_mac 'out' (CRC-valid) on 'valid' and CRC-failed frames on
      'failed' (requires the patched ieee802_11 with the 'failed' port). BER is
      computed vs the KNOWN TX payload: FRID magic + per-frame [A-Za-z0-9] filler
      derived deterministically from (seed, frame_id) -- IDENTICAL to the TX block
      exp3_varied_payload_id in wifi_tx_varied.grc -- with the 4 id bytes excluded.
      This makes a true BER possible even though the payload varies every frame.
      Failed frames whose per-frame match-BER >= noise_threshold are treated as noise
      false-syncs and discarded. Prints every report_sec, and a flushed FINAL summary
      on stop(), so a timed/Ctrl-C run always ends with the cumulative BER.

      When ZERO bit errors are observed the reported BER is the theoretical 95% upper
      confidence bound 2.996/N (rule of three), flagged '[0-err 95%UB]', not 0.

      NB: `seed` must equal the TX block's seed, and PDU_LENGTH its pdu_length.
      """
      import time
      import struct
      import random
      import string
      import pmt
      from gnuradio import gr

      MAC_HDR_LEN = 24
      MAGIC = b'FRID'
      PDU_LENGTH = 500
      FILL_LEN = PDU_LENGTH - 8
      ALPHABET = string.ascii_letters + string.digits   # fixed order; MUST match the TX block
      _POPCOUNT = bytes(bin(i).count('1') for i in range(256))


      def frid_filler(seed, frame_id, n):
          """Deterministic per-frame filler from (seed, frame_id); identical to TX."""
          rng = random.Random(((int(seed) & 0xFFFFFFFF) << 32) | (int(frame_id) & 0xFFFFFFFF))
          return bytes(ord(rng.choice(ALPHABET)) for _ in range(n))


      class blk(gr.basic_block):
          def __init__(self, report_sec=2.0, noise_threshold=0.30, seed=0):
              gr.basic_block.__init__(self, name='ber_sink', in_sig=[], out_sig=[])
              self.report_sec = float(report_sec)
              self.noise_threshold = float(noise_threshold)
              self.seed = int(seed)
              self.valid = 0
              self.failed = 0
              self.discarded = 0
              self.err_bits = 0
              self.tot_bits = 0
              self.ids = set()
              self.id_min = None
              self.id_max = None
              self.t0 = time.time()
              self.t_last = self.t0
              self.message_port_register_in(pmt.intern('valid'))
              self.message_port_register_in(pmt.intern('failed'))
              self.set_msg_handler(pmt.intern('valid'), self.handle_valid)
              self.set_msg_handler(pmt.intern('failed'), self.handle_failed)
              # Startup filler fingerprint: must match the TX block's line exactly.
              # A mismatch means TX and RX disagree on seed/scheme -> BER will be bogus.
              fp = frid_filler(self.seed, 0, 8).decode() + '|' + frid_filler(self.seed, 1, 8).decode()
              print('[filler-fp] RX ber_sink seed=%d fp=%s' % (self.seed, fp), flush=True)

          def handle_valid(self, msg):
              self._handle(msg, True)

          def handle_failed(self, msg):
              self._handle(msg, False)

          def _bit_errors(self, got, exp):
              n = min(len(got), len(exp))
              e = 0
              for i in range(n):
                  e += _POPCOUNT[got[i] ^ exp[i]]
              return e, n * 8

          def _report(self, final=False):
              now = time.time()
              rx = self.valid + self.failed
              # Measured BER, except when ZERO bit errors are observed: 0 errors does not
              # prove BER==0, it only bounds it. Report the theoretical 95% upper
              # confidence bound (rule of three: -ln(0.05)=2.996) => BER = 2.996 / N.
              zero_ub = False
              if self.tot_bits:
                  ber = self.err_bits / self.tot_bits
                  if self.err_bits == 0:
                      ber = 2.996 / self.tot_bits
                      zero_ub = True
              else:
                  ber = 0.0
              fer = self.failed / rx if rx else 0.0
              tag = '[ber] FINAL' if final else '[ber]'
              line = ('%s t=%5.1fs rx=%d (ok=%d fail=%d) noise-drop=%d FER_rx=%4.1f%% BER=%.2e%s (%d/%d)'
                      % (tag, now - self.t0, rx, self.valid, self.failed, self.discarded,
                         100 * fer, ber, ' [0-err 95%UB]' if zero_ub else '',
                         self.err_bits, self.tot_bits))
              if self.ids:
                  span = self.id_max - self.id_min + 1
                  line += '  decode-rate=%4.1f%% (%d/%d)' % (100.0 * len(self.ids) / span, len(self.ids), span)
              print(line, flush=True)
              self.t_last = now

          def _handle(self, msg, ok):
              try:
                  data = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception:
                  return
              msdu = data[MAC_HDR_LEN:]
              if len(msdu) < 8:
                  return
              fid = struct.unpack('>I', msdu[4:8])[0]
              exp_fill = frid_filler(self.seed, fid, FILL_LEN)
              eb_m, tb_m = self._bit_errors(msdu[:4], MAGIC)
              eb_f, tb_f = self._bit_errors(msdu[8:PDU_LENGTH], exp_fill)
              eb = eb_m + eb_f
              tb = tb_m + tb_f
              if not ok:
                  frame_ber = eb / tb if tb else 1.0
                  if frame_ber >= self.noise_threshold:
                      self.discarded += 1
                      return
              self.err_bits += eb
              self.tot_bits += tb
              if ok:
                  self.valid += 1
                  self.ids.add(fid)
                  self.id_min = fid if self.id_min is None else min(self.id_min, fid)
                  self.id_max = fid if self.id_max is None else max(self.id_max, fid)
              else:
                  self.failed += 1
              if time.time() - self.t_last >= self.report_sec:
                  self._report()

          def stop(self):
              # Called when the flowgraph stops (incl. SIGTERM from `timeout` and
              # Ctrl-C): emit the cumulative FINAL BER, flushed so it is not lost.
              print('\n================ BER summary ================', flush=True)
              self._report(final=True)
              print('=============================================', flush=True)
              return True
    noise_threshold: '0.3'
    report_sec: '2.0'
    seed: '0'
  states: {}

connections:
- [ieee802_11_decode_mac_0, out, ber_sink_0, valid]
- [ieee802_11_decode_mac_0, failed, ber_sink_0, failed]
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_tag_share_0, '0', blocks_throttle_0, '0']
- [blocks_tags_strobe_0, '0', blocks_tag_share_0, '1']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [ieee802_11_decode_mac_0, out, frame_logger, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_decode_mac_0, out, link_stats, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_share_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
