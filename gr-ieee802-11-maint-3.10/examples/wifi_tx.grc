options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_tx_updated
    output_language: python
    run_options: run
  states: {}

blocks:
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2450.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 33 | 3300.0 | 11g'',   '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2450000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 3300000000.0,5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2450000000.0'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: lo_offset
  id: variable_qtgui_chooser
  parameters:
    num_opts: '3'
    option0: '0'
    option1: 6e6
    option2: 11e6
    type: real
    value: '0'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '500'
  states: {}
- name: sample_rate
  id: variable_qtgui_chooser
  parameters:
    labels: '["5 MHz", "10 MHz", "20 MHz"]'
    num_opts: '0'
    options: '[5e6, 10e6, 20e6]'
    type: real
    value: 5e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/cse-nghose-25/T9/Data/session12/temp/test.txt
    type: complex
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    period: interval
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    minoutbuf: '100000'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0,)
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: out_buf_size
    pad_front: '100'
    pad_tail: '1000'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 255]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: '"serial=325426C"'
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: packet_len
    samp_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: sample_rate
    chan_est: ieee802_11.LS
    encoding: ieee802_11.Encoding(encoding)
    frequency: freq
    sensitivity: '0.56'
  states: {}
- name: frame_recorder_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """frame_recorder: sink that writes every input sample to frame_file (the exact
          baseband stream sent to the USRP) and writes a per-frame index to index_file with
          columns: frame_id,burst_offset,burst_len,data_offset,data_len (sample units).

          It counts 'packet_len' tagged-stream bursts at packet_pad2's output; burst order ==
          stamped over-the-air frame_id (1 strobe -> 1 PDU -> 1 burst). The packet_len tag
          value is the PADDED burst length (bursts are contiguous, back-to-back in the file).
          The inner non-zero frame is [data_offset, data_offset+data_len), i.e. the burst with
          the pad_front leading zeros and pad_tail trailing zeros removed -- align perturbation
          to that inner span in step 5."""
          def __init__(self, frame_file='/dev/shm/frame.bin', index_file='/dev/shm/frame_index.csv', pad_front=100, pad_tail=1000):
              gr.sync_block.__init__(self, name='frame_recorder', in_sig=[np.complex64], out_sig=None)
              self.frame_file = frame_file
              self.index_file = index_file
              self.pad_front = int(pad_front)
              self.pad_tail = int(pad_tail)
              self.frame_id = 0
              self._f = None
              self._idx = None
              self._len_tag = pmt.intern('packet_len')

          def start(self):
              self._f = open(self.frame_file, 'wb')
              self._idx = open(self.index_file, 'w')
              self._idx.write('frame_id,burst_offset,burst_len,data_offset,data_len\n'); self._idx.flush()
              return True

          def stop(self):
              if self._f: self._f.close()
              if self._idx: self._idx.close()
              return True

          def work(self, input_items, output_items):
              in0 = input_items[0]
              n = len(in0)
              in0.tofile(self._f)
              tags = self.get_tags_in_window(0, 0, n, self._len_tag)
              for t in tags:
                  off = int(t.offset)
                  try:
                      blen = int(pmt.to_long(t.value))
                  except Exception:
                      blen = int(pmt.to_python(t.value))
                  data_off = off + self.pad_front
                  data_len = blen - self.pad_front - self.pad_tail
                  self._idx.write(f'{self.frame_id},{off},{blen},{data_off},{data_len}\n')
                  self.frame_id += 1
              self._idx.flush()
              return n
    frame_file: '''/media/cse-nghose-25/T9/Data/session14/enrollment/device_%d/frame_run_%d.bin''%(device_id, run_id)'
    index_file: '''/media/cse-nghose-25/T9/Data/session14/enrollment/device_%d/frame_index_run_%d.csv''%(device_id,run_id)'
    pad_front: '100'
    pad_tail: '1000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """exp3 varied payload + recoverable OTA frame ID (content-rich enrollment).

      On each strobe trigger emit one PDU on 'out' with payload =
          b'FRID' + uint32_BE(frame_id) + per-frame random [A-Za-z0-9] filler
      totalling pdu_length bytes. The filler is derived deterministically from
      (seed, frame_id), so the RX (ber_sink) can regenerate the exact expected
      payload from the decoded frame_id and measure a TRUE BER, while content still
      varies every frame. Each emitted frame_id is appended to id_log.
      """
      import pmt
      import random
      import string
      import struct
      from gnuradio import gr

      MAGIC = b'FRID'
      ALPHABET = string.ascii_letters + string.digits   # fixed order; RX ber_sink MUST match


      def frid_filler(seed, frame_id, n):
          """Deterministic per-frame filler from (seed, frame_id); identical on RX."""
          rng = random.Random(((int(seed) & 0xFFFFFFFF) << 32) | (int(frame_id) & 0xFFFFFFFF))
          return bytes(ord(rng.choice(ALPHABET)) for _ in range(n))


      class blk(gr.basic_block):
          """Emit FRID+uint32(frame_id)+per-frame-seeded filler; log each id to id_log."""

          def __init__(self, pdu_length=1500, seed=0, id_log='/dev/shm/tx_ids.csv'):
              gr.basic_block.__init__(self, name='exp3_varied_payload_id', in_sig=[], out_sig=[])
              self.pdu_length = int(pdu_length)
              self.seed = int(seed)
              self.id_log = id_log
              self.fid = 0
              self._log = None
              self.message_port_register_in(pmt.intern('trig'))
              self.message_port_register_out(pmt.intern('out'))
              self.set_msg_handler(pmt.intern('trig'), self.handle)
              # Startup filler fingerprint: must match the RX ber_sink's line exactly.
              # A mismatch means TX and RX disagree on seed/scheme -> BER will be bogus.
              fp = frid_filler(self.seed, 0, 8).decode() + '|' + frid_filler(self.seed, 1, 8).decode()
              print('[filler-fp] TX exp3_varied_payload_id seed=%d fp=%s' % (self.seed, fp), flush=True)

          def handle(self, _msg):
              if self._log is None:
                  try:
                      self._log = open(self.id_log, 'w')
                      self._log.write('frame_id\n'); self._log.flush()
                  except Exception:
                      self._log = False
              n = max(8, int(self.pdu_length))
              header = MAGIC + struct.pack('>I', self.fid & 0xFFFFFFFF)
              filler = frid_filler(self.seed, self.fid, n - 8)
              payload = header + filler
              vec = pmt.init_u8vector(len(payload), list(payload))
              self.message_port_pub(pmt.intern('out'), pmt.cons(pmt.PMT_NIL, vec))
              if self._log:
                  self._log.write(f'{self.fid}\n'); self._log.flush()
              self.fid += 1
    id_log: '''/media/cse-nghose-25/T9/Data/session14/enrollment/device_%d/tx_ids_run_%d.csv''%(device_id,run_id)'
    pdu_length: pdu_length
    seed: '0'
  states: {}
- name: device_id
  id: variable
  parameters:
    value: '6'
  states: {}
- name: run_id
  id: variable
  parameters:
    value: '2'
  states: {}

connections:
- [blocks_message_strobe_0_0, strobe, epy_block_0, trig]
- [epy_block_0, out, ieee802_11_mac_0, app in]
- [foo_packet_pad2_0, '0', frame_recorder_0, '0']
- [blocks_multiply_const_vxx_0, '0', foo_packet_pad2_0, '0']
- [blocks_vector_source_x_0, '0', wifi_phy_hier_0, '0']
- [foo_packet_pad2_0, '0', uhd_usrp_sink_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [network_socket_pdu_0, pdus, ieee802_11_mac_0, app in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [wifi_phy_hier_0, '0', blocks_multiply_const_vxx_0, '0']
- [wifi_phy_hier_0, '0', qtgui_freq_sink_x_0, '0']
- [wifi_phy_hier_0, mac_out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
